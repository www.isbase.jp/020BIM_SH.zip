Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 0bf2b43a-6102-4418-b428-4da8559a771d, VersionGUID: 20fe0ee9-ef3a-44ad-ba29-3399024e2e04, NumberOfSaves: 11], CoordinateReference [CoordinateBase: 共有座標]
File name: SHシリーズ.ifc
Time: 2025-10-31T16:34:56+09:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.30.30 (JPN) - IFC 25.4.30.30

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: レベル:レベル 1, レベル 1
LongName: レベル 1; Elevation: 0 mm

# IfcBuildingElementProxy: ISベース_SH:SH151, ISベース_SH:SH151:4553
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH151; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH171, ISベース_SH:SH171:6915
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH171; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH172, ISベース_SH:SH172:6916
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH172; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH201, ISベース_SH:SH201:6935
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH201; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH202, ISベース_SH:SH202:6936
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH202; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH203, ISベース_SH:SH203:9822
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH203; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH204, ISベース_SH:SH204:9830
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH204; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH251, ISベース_SH:SH251:6944
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH251; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH252, ISベース_SH:SH252:6945
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH252; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH253, ISベース_SH:SH253:7153
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH253; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH254, ISベース_SH:SH254:7161
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH254; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH255, ISベース_SH:SH255:9846
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH255; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH301, ISベース_SH:SH301:6957
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH301; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH302, ISベース_SH:SH302:6958
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH302; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH303, ISベース_SH:SH303:7178
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH303; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH304, ISベース_SH:SH304:7186
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH304; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH305, ISベース_SH:SH305:7194
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH305; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH351, ISベース_SH:SH351:6966
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH351; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH352, ISベース_SH:SH352:6967
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH352; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH353, ISベース_SH:SH353:7214
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH353; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH354, ISベース_SH:SH354:7215
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH354; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH355, ISベース_SH:SH355:7216
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH355; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH356, ISベース_SH:SH356:9859
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH356; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH401, ISベース_SH:SH401:6975
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH401; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH402, ISベース_SH:SH402:6976
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH402; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH403, ISベース_SH:SH403:7234
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH403; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH404, ISベース_SH:SH404:7235
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH404; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH405, ISベース_SH:SH405:7236
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH405; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH406, ISベース_SH:SH406:7248
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH406; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH451, ISベース_SH:SH451:6984
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH451; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH452, ISベース_SH:SH452:6985
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH452; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH453, ISベース_SH:SH453:7268
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH453; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH454, ISベース_SH:SH454:7274
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH454; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH455, ISベース_SH:SH455:7282
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH455; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH456, ISベース_SH:SH456:7288
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH456; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH501, ISベース_SH:SH501:6993
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH501; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH502, ISベース_SH:SH502:6994
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH502; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH503, ISベース_SH:SH503:7317
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH503; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH504, ISベース_SH:SH504:7318
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH504; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH505, ISベース_SH:SH505:7319
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH505; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH506, ISベース_SH:SH506:7320
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH506; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH551, ISベース_SH:SH551:7002
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH551; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH552, ISベース_SH:SH552:7003
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH552; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH553, ISベース_SH:SH553:7358
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH553; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH554, ISベース_SH:SH554:7359
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH554; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH555, ISベース_SH:SH555:7360
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH555; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH556, ISベース_SH:SH556:7361
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH556; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH601, ISベース_SH:SH601:7011
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH601; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH602, ISベース_SH:SH602:7012
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH602; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH603, ISベース_SH:SH603:7386
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH603; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH604, ISベース_SH:SH604:7387
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH604; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH605, ISベース_SH:SH605:7388
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH605; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH606, ISベース_SH:SH606:7389
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH606; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH651, ISベース_SH:SH651:7020
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH651; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH652, ISベース_SH:SH652:7021
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH652; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH653, ISベース_SH:SH653:7413
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH653; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH654, ISベース_SH:SH654:7414
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH654; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH655, ISベース_SH:SH655:7415
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH655; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH656, ISベース_SH:SH656:7416
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH656; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH701, ISベース_SH:SH701:7029
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH701; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH702, ISベース_SH:SH702:7030
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH702; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH703, ISベース_SH:SH703:7442
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH703; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH704, ISベース_SH:SH704:7443
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH704; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH705, ISベース_SH:SH705:9877
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH705; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH706, ISベース_SH:SH706:18407
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH706; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH751, ISベース_SH:SH751:7038
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH751; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH752, ISベース_SH:SH752:7039
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH752; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH753, ISベース_SH:SH753:7451
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH753; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH754, ISベース_SH:SH754:7452
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH754; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH755, ISベース_SH:SH755:9891
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH755; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH801, ISベース_SH:SH801:7047
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH801; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH802, ISベース_SH:SH802:7048
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH802; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH803, ISベース_SH:SH803:7460
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH803; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH804, ISベース_SH:SH804:7461
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH804; sets with these values: 2

# IfcBuildingElementProxy: ISベース_SH:SH805, ISベース_SH:SH805:9902
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SH805; sets with these values: 2
